# Keil uVision project kernel-rtef.uvprojx, settings and files
target run (6150000::V6.15::ARMCLANG)
  device: TM4C1294NCPDT Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x040000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: kernel-rtef
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: ARM_CC __FPU_PRESENT
  c include: ..\inc;..\qpc\3rd_party\ucos-ii\Source;..\qpc\3rd_party\ucos-ii\Ports\ARM-Cortex-M\ARMv7-M\ARM;..\qpc\ports\ucos-ii;..\qpc\include;..\qpc\src
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group application
    ../inc/: app_cfg.h os_cfg.h config.h state_machine.h
    ../inc/hsm/: hsm.h periph_util.h
    ../src/hsm/: hsm.c periph_util.c
    ../src/: main.c
  group QP
    ../qpc/src/qf/: qep_hsm.c qep_msm.c qf_act.c qf_defer.c qf_dyn.c qf_ps.c qf_qact.c qf_qeq.c qf_qmact.c qf_time.c
  group QP_port
    ../qpc/ports/ucos-ii/: qf_port.c qep_port.h qf_port.h
  group ucos-ii
    ../qpc/3rd_party/ucos-ii/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group ucos-ii_port
    ../qpc/3rd_party/ucos-ii/Ports/ARM-Cortex-M/ARMv7-M/: os_cpu_c.c
    ../qpc/3rd_party/ucos-ii/Ports/ARM-Cortex-M/ARMv7-M/ARM/: os_cpu.h os_cpu_a.asm os_dbg.c
  group ek-tm4c129
    ./: startup_TM4C129.s system_TM4C129.c
